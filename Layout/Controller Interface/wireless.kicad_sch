File: Layout/Controller Interface/wireless.kicad_sch (KiCad schematic)
At the start: 1 part

Commit message: Update KiCAD project
Parts:
- U3: value ~ -> (none)
